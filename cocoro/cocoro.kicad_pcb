# Repository zoftko/pcrap

## KiCad design cocoro/cocoro.kicad_pcb

File cocoro/README.md:

---
title: Heart shaped RGB LED Array
brief: This board includes a heart shaped RGB LED array and the components to control said array through a simple user interface.
---

# cocoro
The idea behind this board is to function as a night light. It uses an STM8s MCU to control
different characteristics such as color or brightness. The user interface consists of a rotary
encoder and a small I2C OLED display, based on the SD1306 controller.

### Warnings
The P Channel Mosfets (FDN340P) placement to turn on the LEDs (high side switch) is wrong. Pin
assignment is wrong. For example, the PCB layout marks the source as being the gate. The part needs
to be rotated 90° to the left for pins to be properly placed.

Parts:
C1, C4, C6, C7: 100n; C_0603_1608Metric
C2, C5: 100n; C_0805_2012Metric
C3, C8: 1u; C_1206_3216Metric
F1: MINISMDC050F-2; MINISMDC050F2
FB1: 220@100MHz; L_0603_1608Metric
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: USB_B_Micro; USB_Micro-B_SHOU_HAN_MICRO_XNJ_ZB
J2, J3: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
J4: Conn_01x10_Pin; PinHeader_1x10_P2.54mm_Vertical
R1: 5.1k; R_0603_1608Metric
RV1, RV2: V55MLA0603LNR; R_0603_1608Metric
SW1: RotaryEncoder_Switch; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
SW2: SW_Push; SW_SPST_PTS810
U1: DHT11; Aosong_DHT11_5.5x12.0_P2.54mm
U2: STM8S105K6; LQFP-32_7x7mm_P0.8mm

Connections:
5V: C1.1, C3.1, C5.1, C6.1, C7.1, FB1.1, J2.1, J3.2, J4.10, R1.1, U1.1 (VCC), U2.6 (VDD), U2.7 (VDDIO), U2.9 (VDDA); also elsewhere on the board
/FUSED_VBUS: C2.1, F1.2, FB1.2
/PC3: J4.6, U2.20 (PC3)
/PC4: J4.5, U2.21 (PC4)
/PC5: J4.4, U2.22 (PC5)
/PC6: J4.3, U2.23 (PC6)
/PC7: J4.2, U2.24 (PC7)
/PD0: J4.1, U2.25 (PD0)
/VBUS: F1.1, J1.1 (VBUS), RV2.1
ADC0: J4.8, U2.16 (PB0)
ADC1: J4.7, U2.8 (PF4)
CLICK: SW1.S1, U2.17 (PE5)
DHT22: R1.2, U1.2 (IO), U2.32 (PD7)
ENC_A: SW1.A, U2.18 (PC1)
ENC_B: SW1.B, U2.19 (PC2)
EN_BLUE: U2.13 (PB3); also elsewhere on the board
EN_GREEN: U2.14 (PB2); also elsewhere on the board
EN_RED: U2.15 (PB1); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.1, C5.2, C6.2, C7.2, C8.2, J1.5 (GND), J2.2, J3.1, J4.9, RV1.2, SW1.C, SW1.S2, SW2.1, U1.4 (GND), U2.4 (VSS), U2.10 (VSSA); also elsewhere on the board
LE: U2.31 (PD6); also elsewhere on the board
MISO: U2.28 (PD3); also elsewhere on the board
MOSI: U2.29 (PD4); also elsewhere on the board
unnamed: C8.1, U2.5 (VCAP)
PWCLK: U2.27 (PD2); also elsewhere on the board
RST: C4.2, J2.4, SW2.2, U2.1 (~RST)
SCL: J3.3, U2.12 (PB4)
SCLK: U2.30 (PD5); also elsewhere on the board
SDA: J3.4, U2.11 (PB5)
SHLD: J1.6 (Shield), RV1.1, RV2.2
SWIM: J2.3, U2.26 (PD1)

Notes on the sheet:
DHT11/22 SENSOR
PROGRAMMING HEADER
ROTARY ENCODER
I2C SCREEN
RESET CIRCUITRY
MAIN MCU
POWER SUPPLY

Parts:
C9: 1u; C_1206_3216Metric
C10, C11, C12: TBD; C_0805_2012Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16: LED_RKGB; LED_D5.0mm-4_RGB_Staggered_Pins
Q1, Q2, Q3: FDN340P; TSOT-23
R2: 11k; R_0603_1608Metric
U3: LED1642GWTTR; TSSOP-24_4.4x7.8mm_P0.65mm

Connections:
5V: C9.1, C10.1, C11.1, C12.1, Q1.3 (S), Q2.3 (S), Q3.3 (S), U3.24 (VDD); also elsewhere on the board
/ledc/REXT: R2.1, U3.23 (R-EXT)
BLUE: D1.4 (BA), D2.4 (BA), D3.4 (BA), D4.4 (BA), D5.4 (BA), D6.4 (BA), D7.4 (BA), D8.4 (BA), D9.4 (BA), D10.4 (BA), D11.4 (BA), D12.4 (BA), D13.4 (BA), D14.4 (BA), D15.4 (BA), D16.4 (BA), Q3.1 (D)
EN_BLUE: Q3.2 (G); also elsewhere on the board
EN_GREEN: Q2.2 (G); also elsewhere on the board
EN_RED: Q1.2 (G); also elsewhere on the board
GND: C9.2, C10.2, C11.2, C12.2, R2.2, U3.1 (GND); also elsewhere on the board
GREEN: D1.3 (GA), D2.3 (GA), D3.3 (GA), D4.3 (GA), D5.3 (GA), D6.3 (GA), D7.3 (GA), D8.3 (GA), D9.3 (GA), D10.3 (GA), D11.3 (GA), D12.3 (GA), D13.3 (GA), D14.3 (GA), D15.3 (GA), D16.3 (GA), Q2.1 (D)
LE: U3.4 (LE); also elsewhere on the board
MISO: U3.22 (SDO); also elsewhere on the board
MOSI: U3.2 (SDI); also elsewhere on the board
OUT0: D1.2 (K), U3.5 (OUT0)
OUT1: D16.2 (K), U3.6 (OUT1)
OUT2: D15.2 (K), U3.7 (OUT2)
OUT3: D14.2 (K), U3.8 (OUT3)
OUT4: D13.2 (K), U3.9 (OUT4)
OUT5: D12.2 (K), U3.10 (OUT5)
OUT6: D11.2 (K), U3.11 (OUT6)
OUT7: D10.2 (K), U3.12 (OUT7)
OUT8: D9.2 (K), U3.13 (OUT8)
OUT9: D8.2 (K), U3.14 (OUT9)
OUT10: D7.2 (K), U3.15 (OUT10)
OUT11: D6.2 (K), U3.16 (OUT11)
OUT12: D5.2 (K), U3.17 (OUT12)
OUT13: D4.2 (K), U3.18 (OUT13)
OUT14: D3.2 (K), U3.19 (OUT14)
OUT15: D2.2 (K), U3.20 (OUT15)
PWCLK: U3.21 (PWCLK); also elsewhere on the board
RED: D1.1 (RA), D2.1 (RA), D3.1 (RA), D4.1 (RA), D5.1 (RA), D6.1 (RA), D7.1 (RA), D8.1 (RA), D9.1 (RA), D10.1 (RA), D11.1 (RA), D12.1 (RA), D13.1 (RA), D14.1 (RA), D15.1 (RA), D16.1 (RA), Q1.1 (D)
SCLK: U3.3 (CLK); also elsewhere on the board

Notes on the sheet:
LED DRIVER
LED STRIP
RGB LED COLOR SWITCHING

Board: 4 copper layers, 100.0 x 100.0 mm, 50 parts (0 on the bottom side), 50 nets.

## KiCad design pcroast/pcroast.kicad_pcb

File pcroast/README.md:

---
title: Reflow Oven Controller
brief: This board uses a Pico W and integrates several components required to control a simple electrical oven and turn it into a reflow oven for SMD components.
---

# pcroast
This is an all in one PCB to control retrofitted electrical ovens. The only
component that is not part of the PCB is the SSR used to turn on and off the oven. Its main
features are:

* Simple UI with two buttons and 160x128 1.8' display.
* Integrated MAX6675 for temperature readings.
* Zero Cross Detector for counting AC cycles.

## Modules
The schematic splits components into logical modules, some of them, like user buttons or the LCD
header are self explanatory. This section explains modules which are more nuanced.

### Power input
The power input consists of a varistor for voltage spike supression and a PI filter to reduce
noise. An optional LED to indicate the power is ON can be soldered. The module ends with a
PNP diode used to isolate VSYS from VBUS. This makes it possible to connect the Pico W to a USB
port while the board is powered on.

When no USB connection is provided, the Pico W is powered from the DC barrel jack on the board,
when USB power is supplied, VBUS turns off the PNP diode and the Pico W obtains its power from
the USB port.

### Zero Cross Detector (ZCD)
This same schematic can be found as a separate board in this project (ZCD393). It provides a square
wave which makes it easy for the MCU to count AC cycles. It depends on a suitable AC signal being
provided on its set of screw terminals. The voltage can be further decreased by the voltage
divider on board. It should be kept below 1.8V (VCC - 1.5).

### GPIO Outputs
Most GPIO outputs are buffered by logic level NPN MOSFETs. This reduces current consumption when
driving parallel outputs and prevents current consumption to exceed safe limits.

## Testing
A previous revision of this board was fabricated and tested. The only issues found which are
corrected on this version were:

* Negative thermocouple probe was not grounded.
* ZCD used the 5V rail as its supply, instead of 3.3V. This meant its output was a 5V square wave.
  5V are not officially supported by RP2040 GPIO pins, however it does not blow it apart. Just
  to be safe it was changed to the 3.3V rail for safety.

Other than that the design was satisfactory and proved functional.

Parts:
BZ1: Buzzer; Buzzer_12x9.5RM7.6
C1, C4, C5: 0.1u; C_0805_2012Metric
C2, C3: 1u; C_1206_3216Metric
D1, D3, D4, D5: LED; LED_0603_1608Metric
D2: 1N5819WS; D_SOD-123
FB1: 220@100MHz; L_0603_1608Metric
J1, J3, J5: Screw_Terminal_01x02; KF7.62
J2: Barrel_Jack_Switch; BarrelJack_Wuerth_6941xx301002
J4: Conn_01x08_Pin; PinSocket_1x08_P2.54mm_Vertical
J6: Conn_01x02_Pin; PinSocket_1x02_P2.54mm_Vertical
J7: Conn_01x03_Pin; PinSocket_1x03_P2.54mm_Vertical
Q1, Q3, Q4, Q5: IRLML2502; SOT-23
Q2: FDN340P; SOT-23
R1: 8.2k; R_0603_1608Metric
R2: 2.7k; R_0603_1608Metric
R3, R8, R13, R14: 1k; R_0603_1608Metric
R4: 6.8k; R_0603_1608Metric
R5, R6, R7: 220k; R_0603_1608Metric
R9: 10MEG; R_0603_1608Metric
R10, R11, R12: 10k; R_0603_1608Metric
RV1: V55MLA0603LNR; R_0603_1608Metric
SW1, SW2, SW3: SW_Push; SW_SPST_PTS810
U1: MAX6675; SOIC-8_3.9x4.9mm_P1.27mm
U2: LM393; SOIC-8_3.9x4.9mm_P1.27mm
U3: PicoW; RPi_PicoW_SMD_TH

Connections:
/BUZZER: BZ1.1 (-), U3.4 (GPIO2)
/COLR: D5.1 (K), R14.1
/DETIN: R4.1, R5.2, U2.2 (-)
/DETOUT: R9.1, R10.1, U2.1, U3.9 (GPIO6)
/DETREF: R6.2, R7.1, R9.2, U2.3 (+)
/GPIO26: J7.1, U3.31 (GPIO26_ADC0)
/GPIO27: J7.2, U3.32 (GPIO27_ADC1)
/GPIO28: J7.3, U3.34 (GPIO28_ADC2)
/IDLR: D3.1 (K), R8.1
/LED_COOLING: Q5.1 (G), U3.12 (GPIO9)
/LED_IDLE: Q3.1 (G), U3.15 (GPIO11)
/LED_WORKING: Q4.1 (G), U3.14 (GPIO10)
/NUSED+: R12.2, U2.5 (+)
/NUSED-: R11.2, U2.6 (-)
/ONR: D1.1 (K), R3.2
/RUN: J4.4, SW3.1, U3.30 (RUN)
/RX: J6.2, U3.2 (GPIO1)
/SPI0_TFT_CS: J4.3, U3.22 (GPIO17)
/SPI0_TFT_MOSI: J4.6, U3.25 (GPIO19)
/SPI0_TFT_SCK: J4.7, U3.24 (GPIO18)
/SPI1_6675_CS: U1.6 (~CS), U3.17 (GPIO13)
/SPI1_6675_MISO: U1.7 (SO), U3.16 (GPIO12)
/SPI1_6675_SCK: U1.5 (SCK), U3.19 (GPIO14)
/SSR_CTRL: Q1.1 (G), U3.5 (GPIO3)
/SSR_MOSFET_GND: J3.1, Q1.3 (D)
/START_BTN: SW1.1, U3.27 (GPIO21)
/STOP_BTN: SW2.1, U3.29 (GPIO22)
/T+: J1.2, U1.3 (T+)
/TFT_DC: J4.5, U3.26 (GPIO20)
/TX: J6.1, U3.1 (GPIO0)
/VACATT: D2.1 (K), R1.2, R2.2, R4.2
/VBUS: Q2.1 (G), U3.40 (VBUS)
/VIN: C2.1, FB1.2, J2.1, RV1.1
/VSYS: Q2.3 (D), U3.39 (VSYS)
/WRKR: D4.1 (K), R13.1
unnamed: Q3.3 (D), R8.2
unnamed: Q4.3 (D), R13.2
unnamed: Q5.3 (D), R14.2
VAC: J5.1, R1.1

Notes on the sheet:
USER BUTTONS
SSR CONTROL
ZERO CROSS DETECTOR
POWER INPUT
MAX6675
BUZZER
LED OUTPUTS
TFT LCD HEADER
Reflow oven controller based on a Pico W board. Uses MAX6675 ICs for temperature sensing. Drives LCD SPI displays. Capable of activating SSRs that work with 5V.

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
Board: 4 copper layers, 99.6 x 70.0 mm, 45 parts (0 on the bottom side), 42 nets.

## KiCad design zcd393/zcd393.kicad_pcb

File zcd393/README.md:

---
title: Zero Cross Detector
brief: This board features a common circuit found in application notes for the LM393 comparator. It detects zero crossings on AC signals.
---

# zcd393
This is a zero cross detector which produces a square wave whose polarity changes whenever the AC
signal fed to it crosses the zero voltage line. The schematic used in this circuit can be found
in application notes from  different manufacturers and on "Motorola's 1993 Linear Interface ICs".

Component values may be changed to work with different voltage levels. The values in this
iteration were chosen and tested for 12V AC signals. In theory, with the proper voltage divider,
this circuit should work with mains voltage, just be sure not to electrocute yourself.
I personally preferred to use a 120 to 12V transformer.

Parts:
C1: 0.1u; C_0805_2012Metric
D1: 1N5819WS; D_SOD-123
J1: Screw_Terminal_01x02; KF7.62
J2: Conn_01x05_Pin; PinHeader_1x05_P2.54mm_Vertical
R1, R2, R10: 10k; R_0603_1608Metric
R3: 8.2k; R_0603_1608Metric
R4: 2.7k; R_0603_1608Metric
R5: 6.8k; R_0603_1608Metric
R6, R8: 220k; R_0603_1608Metric
R7: 15k; R_0603_1608Metric
R9: 10MEG; R_0603_1608Metric
TP1, TP2: TestPoint; TestPoint_THTPad_4.0x2.0mm
TP3: TestPoint; TestPoint_Pad_D1.0mm
U1: LM393; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
/ACATT: D1.1 (K), R3.2, R4.1, R5.1
/NUSED+: R1.2, U1.5 (+)
/NUSED-: R2.2, U1.6 (-)
/OUT: J2.3, J2.4, J2.5, R9.2, R10.2, U1.1
/ZCDIN: R5.2, R6.2, TP3.1, U1.2 (-)
/ZCDREF: R7.1, R8.2, R9.1, U1.3 (+)
GND: C1.2, D1.2 (A), J1.2, J2.1, J2.2, R1.1, R2.1, R4.2, R7.2, TP2.1, U1.4 (V-)
VAC: J1.1, R3.1
VCC: C1.1, R6.1, R8.1, R10.1, TP1.1, U1.8 (V+)

Notes on the sheet:
POWER INPUT
ZERO CROSS DETECT
UNUSED COMPARATOR

Board: 4 copper layers, 25.0 x 38.0 mm, 18 parts (0 on the bottom side), 9 nets.

## KiCad design filscrete-8bp/filscrete-8bp.kicad_pcb

File filscrete-8bp/README.md:

---
title: 8th Order Bandpass Filter
tags: ["RF", "Filter"] 
---
# Introduction
This is a board designed to function as the layout for 8th order bandpass filters. It was designed with
VHF in mind (original design had a center frequency of 150 MHz).

It has been designed as a two layer board to reduce costs. Most components are 0603, some of the series
inductors are relatively big at VHF frequencies and therefore have been used in 0805 and 1008 sizes. A rare capacitor
value was only available in 0805 packaging at the time so that was used as well.

# Design
## Transmission Lines
The traces are relatively short, and at the target frequencies may not be considered as transmission lines, regardless
the traces were modeled as coplanar wave guides with a ground plane below it. 

Trace width is approximately 0.66mm, spacing between the planar planes is 0.13mm and spacing between
the trace and ground plane below it should be 1.6mm, according to Kicad this gives a Z0 close to 50 Ohms.

## Filter Synthesis
The original design was generated following Steve's Winder advice on Chapter 6 of his book
"Analog and Digital Filter Design". Below are the details:

* Center Frequency: 150 MHz
* Bandwidth: 20 MHz
* Type: Butterworth
* Rs, RL: 50 Ohms

| Component | Value | Package (in) |
|:---------:|:-----:|:------------:|
|    C1     | 160pF |     0805     |
|    L1     | 6.8nH |     0603     |
|    L2     |  1uH  |     1008     |
|    C2     |  1pF  |     0603     |
|    C3     | 390pF |     0603     |
|    L3     | 2.7nH |     0603     |
|    L4     | 390nH |     0805     |
|    C4     | 2.7pF |     0603     |

Parts:
C1: C; C_0805_2012Metric
C2, C3, C4: C; C_0603_1608Metric
IN1: Conn_Coaxial; SMA_EdgeMount
L1, L3: L; L_0603_1608Metric
L2: L; L_1008_2520Metric
L4: L; L_0805_2012Metric
OUT1: Conn_Coaxial; SMA_EdgeMount

Connections:
GND: C1.2, C3.2, IN1.2 (Ext), L1.2, L3.2, OUT1.2 (Ext)
unnamed: C2.1, L2.2
unnamed: C2.2, C3.1, C4.2, L3.1
unnamed: C4.1, L4.2
unnamed: C1.1, IN1.1 (In), L1.1, L2.1
unnamed: L4.1, OUT1.1 (In)

Notes on the sheet:
DISCRETE 8TH ORDER BANDPASS FILTER LAYOUT

Board: 2 copper layers, 46.3 x 16.0 mm, 10 parts (0 on the bottom side), 6 nets.

## KiCad design sam/sam.kicad_pcb

Parts:
C1, C2: 1u; C_1206_3216Metric
C3: 100n; C_0805_2012Metric
C4, C5, C6: 100n; C_0603_1608Metric
D1: DTS2042-04TS; TSOT-23-6
FB1: FerriteBead; L_0805_2012Metric
J1: USB_A; USB_A_MOLEX_480372000
J2: Conn_Coaxial; SMA_EdgeMount
R1: 100k; R_0603_1608Metric
U1: SPIRIT1; QFN-20-1EP_4x4mm_P0.5mm_EP2.5x2.5mm
U2: LDLN030; TSOT-23-5
U3: STM32F070C6Tx; LQFP-48_7x7mm_P0.5mm

Connections:
3V3: C3.1, C4.1, C5.1, C6.1, FB1.2, U3.1 (VDD), U3.9 (VDDA), U3.24 (VDD), U3.36 (VDD), U3.48 (VDD)
/5V: C1.1, D1.4, J1.1 (VBUS), U2.1 (VIN), U2.3 (EN)
/LDO: C2.1, FB1.1, R1.1, U2.5 (OUT)
CS: U1.5 (~CS), U3.42 (PB6)
D+: D1.1, J1.3 (D+), U3.33 (PA12)
D-: D1.3, J1.2 (D-), U3.32 (PA11)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, D1.2, J1.4 (GND), J1.5 (Shield), J2.2 (Ext), U1.11 (GND_PA), U1.21 (GND), U2.2 (GND), U3.8 (VSSA), U3.23 (VSS), U3.35 (VSS), U3.47 (VSS)
MISO: U1.2 (MISO), U3.40 (PB4)
MOSI: U1.3 (MOSI), U3.41 (PB5)
unnamed: R1.2, U2.4 (PG)
SCLK: U1.4 (SCLK), U3.39 (PB3)

Notes on the sheet:
SAM - SPIRIT1 BASED TRANSCEPTOR
153 MHz Digital Modulation Transceptor. Made to fit in a USB pen drive

Board: 4 copper layers, 14 parts (0 on the bottom side), 11 nets, no tracks yet.
