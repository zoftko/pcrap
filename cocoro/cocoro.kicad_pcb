# Repository zoftko/pcrap (continued)

## KiCad design ev1496/ev1496.kicad_pcb

Parts:
C1, C2: 100n; C_0603_1608Metric
C3, C4, C7: 10n; C_0603_1608Metric
C5, C6: 1n; C_0603_1608Metric
C8, C9: C; C_0603_1608Metric
FB1: FerriteBead; L_0805_2012Metric
J1: Barrel_Jack_Switch; BarrelJack_GCT_DCJ200-10-A_Horizontal
J2, J3, J4: Conn_Coaxial; SMA_EdgeMount
L1: L; L_0603_1608Metric
R1, R8: 10k; R_0603_1608Metric
R2: 5.1k; R_0603_1608Metric
R3: 6.8k; R_0603_1608Metric
R4: 8.2k; R_0603_1608Metric
R5, R6: 51; R_0603_1608Metric
R7: 1k; R_0603_1608Metric
R9, R10, R11: 3.9k; R_0603_1608Metric
U1: MC1496; DIP-14_W7.62mm

Connections:
/AC_OUT: C7.1, C8.1, L1.1
/BIAS: R8.2, U1.5 (BIAS)
/BIAS_SERIES: R8.1, R9.2
/CARRIER: C5.2, R5.2, U1.10 (CARRIER)
/CARRIER_IN: C5.1, J2.1 (In)
/OUT: C7.2, R11.2, U1.12 (OUTPUT)
/SIGNAL: C6.2, R6.1, U1.1 (SIGNAL)
/SIG_IN: C6.1, J3.1 (In)
/TUNED_OUT: C9.1, J4.1 (In), L1.2
/UNUSED_OUT: R10.2, U1.6 (OUTPUT)
/VIN: C1.1, FB1.1, J1.1
CARRIER_BIAS: C4.1, R3.2, R4.1, R5.1, U1.8 (CARRIER)
GND: C1.2, C2.2, C3.2, C4.2, C8.2, C9.2, J1.2, J2.2 (Ext), J3.2 (Ext), J4.2 (Ext), R2.2, R4.2, U1.14 (VEE)
unnamed: R7.1, U1.2 (GAIN)
unnamed: R7.2, U1.3 (GAIN)
SIGNAL_BIAS: C3.1, R1.2, R2.1, R6.2, U1.4 (SIGNAL)
VCC: C2.1, FB1.2, R1.1, R3.1, R9.1, R10.1, R11.1

Notes on the sheet:
MC1496 EVALUATION BOARD
DC BIAS
POWER SUPPLY
April 02 2023

Board: 4 copper layers, 27 parts (13 on the bottom side), 17 nets, no tracks yet.

## Commit log

2023-04-08 Added MC1496 evaluation board
2023-04-29 Add 8th order bandpass filter PCB layout
2023-05-09 Add cocoro - STM8 RGB LED Driver
    Interactive RGB LED Driver. LEDs form a heart shape.
    Added schematics and footprints for components which
    were missing from the standard Kicad Library
2023-05-15 Start work on SPIRIT1 transceiver
2023-05-19 Add 4 channel TVS diode array to lib
2023-05-23 Added low noise LDO and USB plug footprint
    A low noise LDO for use in sam has been added, together
    with the footprint for a Molex USB A plug.
2023-05-25 cocoro: imp vbus protection, changed nets
    Removed ESD and added two MLVs according to Littelfuse application
    notes to protect the USB port from overvoltage. Changed nets for LEDs
    to improve routing and moved the LED driver to what seems a better
    position.
    Added some extra components (rotary encoder among others) to the board.
2023-05-26 cocoro: Finish MCU and LED driver section
    Passive components were added to the MCU and the connections
    to the led driver were drawn to the schematic. Remaining free
    pins have been connected to headers for external use.
2023-05-31 cocoro: Route board
    The board has been completely routed. Still needs a double check.
    The LED footprint has been changed to something that has more
    space between pins, in order to make it easier to manufacture.
2023-06-06 cocoro: Board touchups and decoupling caps
    Performed minor touchup to reduce the size of ground islands. Added
    some extra vias and decoupling caps for the power MOSFETs, since
    it is recommended to add some extra capacitance to the voltage line
    according to the LED1642 datasheet.
2023-06-07 cocoro: Improve manufacturability and better placement
    Vias on the left side of the LED1642 were far too close to be
    easily manufactured by JLCPCB. Routing has been changed
    to add more clearance to said vias.
    The CORACAO text and version were moved to a better location to
    ensure they are not covered by the DHT22 sensor.
    Traces on LEDs were changed to 4mm to increase clearance between
2023-06-11 cocoro: fix footprints
    * A new USB footprint for the actual product in hand has been added.
    * The footprint for the RESET button was corrected to the actual
    product in hand.
    * Vias under the MCU were moved a little bit more to the center
    for increased clearance from pads.
2023-08-21 Housekeeping, deleted extra-crappy projects, add CI
    Deleted a bunch of half-finished projects that won't be getting
    attention anytime soon:
    * filscrete-8bp: Making a good quality filter for the VHF band will be
    much harder than expected and won't be pursued for the time being.
    * ev1496: Much more investigation needs to be done on the intrinsic
    characteristics of the MC1496 IC before being able to develop an
2023-08-25 Add support for balba
    balba is a tool to build static websites from a collection of Kicad
    projects. This commit adds support for it:
    * Added balba.yaml with setup for Github PagesP
    * Updated cocoro's README with front matter
    * Measurements were removed from the existing PCB since they
    interfered with image creation for balba.
2023-08-25 Create gh-pages.yml
    This new workflow will automatically deploy a static website build with balba to Github Pages.
2023-08-25 Correct missing key for actions/cache
2023-08-25 Fix syntax error on CI yaml
2023-08-25 Install missing kicad dependecy for GH Pages
2023-08-25 Corrected website's base url
    Sorry Github, please don't ban me.
2023-09-06 Add KF7.62 footprint
    The footprint for KF7.62, a two screw terminal has also added. This
    terminal is helfpul when dealing with AC voltages and is compatible with
    fork type cable connectors.
2023-09-25 Add zcd393 board
    ZCD393 is an evaluation board for LM393 comparators,
    it performs the function of a zero cross detector which may
    be helpful to sync MCUs with mains in order to control
    TRIACs or other power electronic components.
    A new footprint for a double sided test pad used in the board has been
    added as well.
2023-09-25 Fix diode footprint
2023-09-25 Add zcd393 board
    ZCD393 is an evaluation board for LM393 comparators,
    it performs the function of a zero cross detector which may
    be helpful to sync MCUs with mains in order to control
    TRIACs or other power electronic components.
2023-09-26 Add pcroast board
    This commit adds a board for controlling reflow ovens. It also adds the
    required schematics and footprints for new pieces:
    * Pico W
    * MAX6675
2023-09-26 Fix supply voltage for ZCD
    It should be fed from 3.3V instead of 5V, as the RP2040 gpio pins should
    not be exposed to 5V.
2023-10-02 fix: ground T- termocouple probe
2023-10-02 add README
2023-10-02 add: pcroast board
    This commit adds a board for controlling reflow ovens. It also adds the
    required schematics and footprints for new pieces:
    * Pico W
    * MAX6675
2024-04-22 Update cocoro to kicad v8, add notes
    Board was originally designed in Kicad 7, Kicad 8 is now out and
    opening boards from older versions automatically converts them so might
    as well do it now.
    There is also an error on the board, it has been noted in its README.
2024-04-22 ci: update kicad version
